# IAR project servo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: D:\Vincross\code\servo-tim8260_serving\STM8S_StdPeriph_Lib\inc; D:\Vincross\fhc\servo-tim8260_serving\Components\support; D:\Vincross\fhc\servo-tim8260_serving\BSP\inc; D:\Vincross\fhc\servo-tim8260_serving\Components\algorithm; D:\Vincross\fhc\servo-tim8260_serving\Components\device; D:\Vincross\fhc\servo-tim8260_serving\Components\memory_control_table; D:\Vincross\fhc\servo-tim8260_serving\Components\controller; D:\Vincross\fhc\servo-tim8260_serving\Components\protocal; D:\Vincross\fhc\servo-tim8260_serving\Components\command_interpreter; D:\Vincross\fhc\servo-tim8260_serving\App
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: servo.hex
  ILINK.IlinkOutputFile: servo.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s003f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group App
    App/: app.c stm8s_it.c
  group BSP
    BSP/src/: drv_adc.c drv_eeprom.c drv_tim.c drv_uart.c
    BSP/inc/: drv_adc.h drv_eeprom.h drv_tim.h drv_uart.h
  group Components/algorithm
    Components/algorithm/: filter.c pid.c
  group Components/command_interpreter
    Components/command_interpreter/: command_interpreter.c
  group Components/controller
    Components/controller/: controller.c
  group Components/controller/protocal
    Components/protocal/: protocal_process.c
  group Components/device
    Components/device/: motor.c
  group Components/mem_ctrl_table
    Components/memory_control_table/: mem_ctl_table.c
  group Components/support
    Components/support/: cyclic_queue.c
  group Doc
    Doc/: backup.md
    ./: README.md
  group STM8S_StdPeriph_Lib
    STM8S_StdPeriph_Lib/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
